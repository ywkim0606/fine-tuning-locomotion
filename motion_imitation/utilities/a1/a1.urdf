Commit message: interval to perturbation for training

File: motion_imitation/utilities/a1/a1.urdf (robot description, URDF)
Before this commit: robot a1_description, 18 links, 17 joints
Links:
- link trunk: geometry collision box size=0.025 0.2 0.025; collision box size=0.05 0.125 0.06
